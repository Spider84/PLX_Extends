# IAR project project.ewp, settings and files
configuration PLX (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD; _USE_DEBUG
  ICCSTM8.CCIncludePath2: ..; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\STM8_EVAL\Common; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\STM8_EVAL; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration stm8l1528-eval (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L152M8 STM8L152M8
  General.GenCodeModel: 2
  ICCSTM8.CCDefines: USE_STM8L1528_EVAL; STM8L15X_HD
  ICCSTM8.CCIncludePath2: ..; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\STM8_EVAL; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\STM8_EVAL\STM8L1528_EVAL; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\STM8_EVAL\Common; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\Misc
  OBJCOPY.OOCOutputFile: project.srec
configuration PLX-ld (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L151C3 STM8L151C3
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: STM8L15X_LD
  ICCSTM8.CCIncludePath2: ..; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\STM8_EVAL; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\STM8_EVAL\STM8L1526_EVAL; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\STM8_EVAL\Common; ..\..\STM8L15x_StdPeriph_Lib_V1.5.1\Utilities\Misc
  OBJCOPY.OOCOutputFile: project.srec
  group STM8L
    ../../STM8L15x_StdPeriph_Lib_V1.5.1/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    ../: fifo.c fluidtemp.c main.c stm8l15x_it.c swuart.c usart_fifo.c
